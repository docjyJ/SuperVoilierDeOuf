# Keil uVision project voilier.uvprojx, settings and files
target SimulBG (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: timer_SBG
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Driver\Include;.\Service;..\Services\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./Sources/: main.c
  group Drivers
    ../Driver/Sources/: Driver_USART.c Driver_ADC.c Driver_GPIO.c Driver_TIMER.c Lib_Com_Periph_2022.lib
  group Service
    ../Services/Sources/: Gestion_adxl345.c Gestion_ds1307_RTC.c Gestion_Telecommande.c Gestion_Girouette.c Gestion_Voiles.c Gestion_Batterie.c
target Reel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: gpio_SBG
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Driver\Include;..\Services\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
